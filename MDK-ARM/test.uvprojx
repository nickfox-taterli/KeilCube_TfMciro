# Keil uVision project test.uvprojx, settings and files
target test (6150000::V6.15::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,TFLM_RUNTIME_USE_ALL_OPERATORS=0,TF_LITE_STATIC_MEMORY,NDEBUG,GEMMLOWP_ALLOW_SLOW_SCALAR_FALLBACK,TF_LITE_MCU_DEBUG_LOG,ARM_MATH,ARM_MATH_DSP,ARM_MATH_LOOPUNROLL,ARM_MATH_CM7,__FPU_PRESENT=1,STM32H723xx
  c include: ../Core/Inc;../Middlewares/tensorflow;../Middlewares/tensorflow/third_party;../Middlewares/tensorflow/third_party/flatbuffers/include;../Middlewares/tensorflow/third_party/gemmlowp;../Middlewares/tensorflow/third_party/ruy;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/X-CUBE-AI/App
    ../Middlewares/tensorflow/: syscalls.c
  group Application/User/Core
    ../Core/Src/: stm32h7xx_it.c main.cpp
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_crc.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_1_x_n_s8.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nntables.c arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s8.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_max_pool_s8_opt.c arm_pool_q7_HWC.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions
    ../Middlewares/tensorflow/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group Middlewares/tensorflow/tensorflow/lite/micro
    ../Middlewares/tensorflow/tensorflow/lite/micro/: all_ops_resolver.cc memory_helpers.cc micro_allocator.cc micro_error_reporter.cc micro_interpreter.cc micro_optional_debug_tools.cc micro_profiler.cc micro_string.cc micro_time.cc micro_utils.cc recording_micro_allocator.cc recording_simple_memory_allocator.cc simple_memory_allocator.cc test_helpers.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/kernels
    ../Middlewares/tensorflow/tensorflow/lite/micro/kernels/: activations.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc dequantize.cc elementwise.cc ethosu.cc floor.cc l2norm.cc logical.cc logistic.cc maximum_minimum.cc neg.cc pack.cc pad.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc split.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/kernels/cmsis-nn
    ../Middlewares/tensorflow/tensorflow/lite/micro/kernels/cmsis-nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc
  group Middlewares/tensorflow/tensorflow/lite/micro/memory_planner
    ../Middlewares/tensorflow/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc
  group Middlewares/tensorflow/tensorflow/lite/c
    ../Middlewares/tensorflow/tensorflow/lite/c/: common.c
  group Middlewares/tensorflow/tensorflow/lite/kernels
    ../Middlewares/tensorflow/tensorflow/lite/kernels/: kernel_util.cc
  group Middlewares/tensorflow/tensorflow/lite/kernels/internal
    ../Middlewares/tensorflow/tensorflow/lite/kernels/internal/: quantization_util.cc
  group Middlewares/tensorflow/tensorflow/lite/core/api
    ../Middlewares/tensorflow/tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
software components: CMSIS:CORE 4.3.0
